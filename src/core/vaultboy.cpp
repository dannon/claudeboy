#include "core/vaultboy.h"
#include "core/font.h"
#include "core/pace.h"
#include "core/screen.h"

namespace cb {
namespace {

// 42x46, one character per pixel: '#' bright, '+' normal, '.' dim, ' ' unlit.
//
// Kept as art rather than as drawing calls because a face is a face -- the
// difference between a grin and a grimace is four pixels, and no amount of
// arcs and ellipses in a function body makes that reviewable. These were
// generated from shape primitives and then hand-tuned; what shipped is what
// was looked at.
const char* const kBoyFine[VB_H] = {
    "                       ##                 ",
    "                      #++##               ",
    "                     #+++++##             ",
    "                     #++++++#             ",
    "          ######### #++++++#              ",
    "       #######+#####++++++#               ",
    "      ##  +++++++++ +++++##               ",
    "     ## +++++++++++++++##                 ",
    "    #  ++++++++++++++## #                 ",
    "   ## +++++++++++++++++ ##                ",
    "   # +++++++++++++++++++ #                ",
    "    +++++++++++++++++++++                 ",
    "    +++++++++++++++++++++                 ",
    "    #                   #                 ",
    "   #                     #      #####     ",
    "   #    #####            #     ##...##    ",
    "   #    #####     ###    #    ##.....##   ",
    "   #    #####    #####   #    #.......#   ",
    "   #    #####            #    #.......#   ",
    "   #    #####            #    #.......#   ",
    "   #                     #    #.......#   ",
    "    #   #           #   #     #.......#   ",
    "    #   +++++++++++++   #     #.......#   ",
    "    #    ###     ###    #    #.........#  ",
    "     #     #######     #    #...........# ",
    "      #               #    #.............#",
    "       #             #     #.............#",
    "        #           #      #...+++++++...#",
    "          #       #        #.............#",
    "          #########        #.............#",
    "                            #...++++++..# ",
    "           #.....#           #.........#  ",
    "         ##.#...#.##        #.#.......#   ",
    "        #...#...#...#      #..#########   ",
    "       #.....#.#.....#    #.....#         ",
    "     ##.......#.......##  #.....#         ",
    "    #...................##......#         ",
    "    #...................#......#          ",
    "   #.+++++++++++++++++++#......#          ",
    "   #...................#.......#          ",
    "   #..................#.......#           ",
    "  #...........................#           ",
    "  #..........................             ",
    "  #.........................              ",
    " #.........................#              ",
    " #                         #              ",
};

const char* const kBoySteady[VB_H] = {
    "                       ##                 ",
    "                      #++##               ",
    "                     #+++++##             ",
    "                     #++++++#             ",
    "          ######### #++++++#              ",
    "       #######+#####++++++#               ",
    "      ##  +++++++++ +++++##               ",
    "     ## +++++++++++++++##                 ",
    "    #  ++++++++++++++## #                 ",
    "   ## +++++++++++++++++ ##                ",
    "   # +++++++++++++++++++ #                ",
    "    +++++++++++++++++++++                 ",
    "    +++++++++++++++++++++                 ",
    "    #                   #                 ",
    "   #                     #                ",
    "   #    #####    #####   #                ",
    "   #    #####    #####   #      #####     ",
    "   #    #####    #####   #   .###...###.  ",
    "   #    #####    #####   #   ##.+..+..+#  ",
    "   #    #####    #####   #   #..+..+..+#  ",
    "   #                     #   #..+..+..+#  ",
    "    #                   #    #..+..+..+#  ",
    "    #    ############   #    #..+..+..+#  ",
    "    #                   #    #..+..+..+#  ",
    "     #                 #     #..+..+..+#  ",
    "      #               #    ##...+..+..+#  ",
    "       #             #    #............#  ",
    "        #           #     #............#  ",
    "          #       #       #............#  ",
    "          #########       ##...........#  ",
    "                            ##.........#  ",
    "           #.....#           #.........#  ",
    "         ##.#...#.##         #.........#  ",
    "        #...#...#...#       ############  ",
    "       #.....#.#.....#     #.....#        ",
    "     ##.......#.......##  #.....#         ",
    "    #...................##......#         ",
    "    #...................##......#         ",
    "   #.+++++++++++++++++++#......#          ",
    "   #...................#.......#          ",
    "   #..................#.......#           ",
    "  #...........................#           ",
    "  #..........................             ",
    "  #.........................              ",
    " #.........................#              ",
    " #                         #              ",
};

const char* const kBoyFried[VB_H] = {
    "         ##    ##   ##                    ",
    "   ##    ##    ##   ##                    ",
    "    #    ##   # #  ##    ##               ",
    "    ##    ##  ##   ##   ##                ",
    "    # #   ##  ##  ##    ##                ",
    "     ##   ##########   ##                 ",
    "      #####+++++++#### ##                 ",
    "      ##+++++++++++++###                  ",
    "    ###+++++++++++++++###                 ",
    "    # +++++++++++++++++ #                 ",
    "   ##+++++++++++++++++++##                ",
    "   #+++++++++++++++++++++#                ",
    "    #                   #                 ",
    "    #                   #                 ",
    "   #                     #                ",
    "   #    #   #    #   #   #    #########   ",
    "   #     # #      # #    #    #.......#   ",
    "   #      #        #     #   #.........#  ",
    "   #     # #      # #    #  #...........# ",
    "   #    #   #    #   #   # #.............#",
    "   #                     # #.............#",
    "    #                   #  #...+++++++...#",
    "    #   +++++++++++++ # #  #.............#",
    "    #    # # # # # # #  #  #.............#",
    "     #  +++++++++++++  #    #...++++++..# ",
    "      #               #      ##.......##  ",
    "       #             #      #.#.......#   ",
    "        #           #       #.#.......#   ",
    "          #       #        #..#.......#   ",
    "          #########        #..#.......#   ",
    "                          #...#.......#   ",
    "           #.....#        #...##.....##   ",
    "         ##.#...#.##     #.....##   ##    ",
    "        #...#...#...#    #......#####     ",
    "       #.....#.#.....#   #.....#          ",
    "     ##.......#.......###......#          ",
    "    #...................#......#          ",
    "    #..................#.......#          ",
    "   #.++++++++++++++++++#.......#          ",
    "   #..................#.......#           ",
    "   #..................#.......#           ",
    "  #...........................#           ",
    "  #..........................             ",
    "  #.........................              ",
    " #.........................#              ",
    " #                         #              ",
};
uint8_t intensity_of(char ch) {
    switch (ch) {
        case '#': return I_BRIGHT;
        case '+': return I_NORMAL;
        case '.': return I_DIM;
        default:  return 0;
    }
}

}  // namespace

BoyMood boy_mood(const Provider& prov, int64_t now_ms) {
    // Same ordering the caption uses, so his face and the words under it can
    // never disagree about which window is the problem.
    switch (worst_pace(prov, now_ms)) {
        case PaceState::Burnout: return BoyMood::Fried;
        case PaceState::Surplus: return BoyMood::Fine;
        case PaceState::Ready:   return BoyMood::Fine;
        // OnPace, and Unknown -- which is also what an unreadable provider
        // comes back as. Nothing readable at all is not good news, so it is
        // not a thumbs up.
        default:                 return BoyMood::Steady;
    }
}

void draw_vault_boy(Canvas& c, int x, int y, BoyMood mood) {
    const char* const* art = kBoySteady;
    if (mood == BoyMood::Fine) art = kBoyFine;
    else if (mood == BoyMood::Fried) art = kBoyFried;

    for (int row = 0; row < VB_H; row++) {
        const char* s = art[row];
        for (int col = 0; col < VB_W && s[col]; col++) {
            const uint8_t v = intensity_of(s[col]);
            if (v) c.plot(x + col, y + row, v);
        }
    }
}

}  // namespace cb
